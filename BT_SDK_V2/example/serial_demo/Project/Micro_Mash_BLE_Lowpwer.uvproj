# Keil uVision project Micro_Mash_BLE_Lowpwer.uvproj, settings and files
target Flash (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Micro_Ble_flash +hex
  c flags: Optim=4
  c misc: --c99
  c include: ..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\Device\Inclue;..\..\..\Libraries\WS_StdPeriph_Driver\inc;..\..\..\lib;..\..\..\hal\uart\int;..\..\..\hal\gpio\int;..\..\..\hal\wdt\int;..\..\..\gap\int;..\..\..\gatt\int;..\..\..\hal\sleep\int;..\..\..\hal\adc\int;..\..\..\hal\timer\int;..\src;..\..\..\hal\key\int;..\..\..\hal\led\int;..\..\..\hal\pwm\int;..\..\..\hal\charge\int;..\..\..\scan\int
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x8000
  memory RVCT9: RAM 0x20000010 size 0xd1c
  link misc: ..\..\..\lib\bt_lib_symbol_flash.txt
  group user
    ../src/: main.c app.c
  group ble_host
    ../../../lib/: Ble_Host_Lib.lib Ble_Host_Mini_Lib.lib
  group cpu
    ../../../Libraries/Device/Source/: startup_cpu.s cpu.c
  group hal
    ../../../hal/uart/src/: uart.c
    ../../../hal/gpio/src/: gpio.c
    ../../../hal/wdt/src/: wdt.c
    ../../../hal/sleep/src/: sleep.c
    ../../../hal/adc/src/: gpadc.c
    ../../../hal/timer/src/: timer.c
    ../../../hal/key/src/: key.c
    ../../../hal/led/src/: led.c
    ../../../hal/pwm/src/: pwm.c
    ../../../hal/charge/src/: charge.c
  group gap
    ../../../gap/src/: ble_gap.c
  group gatt
    ../../../gatt/src/: ble_gatt.c
  group scan
    ../../../scan/src/: ble_scan.c
target Otp (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Micro_Ble_otp +hex
  c flags: Optim=4
  c misc: --c99
  c include: ..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\Device\Inclue;..\..\..\Libraries\WS_StdPeriph_Driver\inc;..\..\..\lib;..\..\..\gatt\int;..\..\..\gap\int;..\..\..\hal\fifo\int;..\..\..\hal\gpio\int;..\..\..\hal\sleep\int;..\..\..\hal\uart\int;..\..\..\hal\wdt\int;..\..\..\hal\timer\int;..\..\..\hal\adc\int;..\..\..\hal\led\int;..\src;..\..\..\hal\key\int;..\..\..\hal\pwm\int;..\..\..\hal\charge\int;..\..\..\scan\int
  library: MicroLIB
  memory RVCT4: ROM 0x4080 size 0x3f80
  memory RVCT9: RAM 0x20000010 size 0xd1c
  link misc: ..\..\..\lib\bt_lib_symbol_otp.txt
